# Keil uVision project Car.uvproj, settings and files
target CarbonFreeCar (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group src
    ./src/: main.c delay.c direction.c distance.c HMC5883.c MPU6050.c oled.c serial.c
